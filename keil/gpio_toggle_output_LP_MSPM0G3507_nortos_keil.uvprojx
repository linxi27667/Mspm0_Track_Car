# Keil uVision project gpio_toggle_output_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target gpio_toggle_output_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_toggle_output_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: E:/MCU/MSPM0/m0_sdk/mspm0_sdk_1_30_00_03/source/third_party/CMSIS/Core/Include;E:/MCU/MSPM0/m0_sdk/mspm0_sdk_1_30_00_03/source;..\BSP\Inc;..\BSP\Src;..\APP\Inc;..\APP\Src;..\TASK;..\RTT EasyLog\RTT_easylog\easylogger\inc;..\RTT EasyLog\RTT_easylog\easylogger\plugins;..\RTT EasyLog\RTT_easylog\easylogger\port;..\RTT EasyLog\RTT_easylog\easylogger\src;..\RTT EasyLog\RTT_easylog\RTT;..\RTT EasyLog\RTT_easylog\easylogger\plugins\file;..\RTT EasyLog\RTT_easylog\easylogger\plugins\flash;..
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../: main.c TI_moban.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group Driverlib
    E:/MCU/MSPM0/m0_sdk/mspm0_sdk_1_30_00_03/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group APP
    ../APP/Src/: app_encoder_motor.c app_key.c app_led.c app_buzzer.c app_uart.c app_path_fish.c app_sw_i2c.c app_oled.c app_imu.c app_pid.c app_esp01s.c app_tuning.c app_safety.c app_tc1.c
    ../APP/Inc/: app_encoder_motor.h app_key.h app_led.h app_buzzer.h app_uart.h app_path_fish.h app_sw_i2c.h app_oled.h app_imu.h app_pid.h app_common.h app_esp01s.h app_esp01s_cfg.h app_tuning.h app_safety.h app_tc1.h
  group TASK
    ../TASK/: track.c track.h imu_health_logic.h
  group BSP
    ../BSP/Src/: bsp_encoder_motor.c bsp_common.c bsp_key.c bsp_led.c bsp_buzzer.c bsp_uart.c bsp_path_fish.c bsp_sw_i2c.c bsp_oled.c bsp_oled_font.c bsp_imu660rb.c bsp_esp_at.c
    ../BSP/Inc/: bsp_encoder_motor.h bsp_common.h bsp_key.h bsp_led.h bsp_buzzer.h bsp_uart.h bsp_path_fish.h bsp_sw_i2c.h bsp_oled.h bsp_oled_font.h bsp_imu660rb.h bsp_esp_at.h
  group Easy_log
    ../RTT EasyLog/RTT_easylog/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../RTT EasyLog/RTT_easylog/easylogger/port/: elog_port.c
    ../RTT EasyLog/RTT_easylog/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
